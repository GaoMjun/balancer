# Keil uVision project balancer.uvproj, settings and files
target balancer (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: balancer +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\bsp;..\cmsis;..\dirver;..\lib\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: startup_stm32f10x_md.s
  group bsp
    ../bsp/: delay.c bsp.c uart1.c
  group driver
    ../dirver/: led.c encoder.c motor.c battery.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../user/: main.c stm32f10x_it.c
  group cmsis
    ../cmsis/: core_cm3.c system_stm32f10x.c
