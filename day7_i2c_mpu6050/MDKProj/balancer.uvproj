# Keil uVision project balancer.uvproj, settings and files
target balancer (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: balancer +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, MPU6050
  c include: ..\bsp;..\cmsis;..\dirver;..\dirver\DMP;..\lib\inc;..\user;..\dirver\eMPL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: startup_stm32f10x_md.s
  group bsp
    ../bsp/: bsp.c delay.c uart1.c
  group cmsis
    ../cmsis/: core_cm3.c system_stm32f10x.c
  group driver
    ../dirver/: battery.c encoder.c led.c motor.c mpu6050.c i2c.c
    ../dirver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group user
    ../user/: stm32f10x_it.c main.c
